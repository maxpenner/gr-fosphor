options:
  parameters:
    generate_options: qt_gui
    id: untitled
    output_language: python
    realtime_scheduling: '1'
    title: Not titled yet
  states: {}

blocks:
- name: dBm_ref_0dBFS
  id: variable
  parameters:
    value: dBm_ref_0dBFS_at_rf_gain_max + (rf_gain_max - rf_gain)
  states: {}
- name: dBm_ref_0dBFS_at_rf_gain_max
  id: variable
  parameters:
    value: '-65'
  states: {}
- name: rf_freq
  id: variable_qtgui_range
  parameters:
    start: 50e6
    step: 10e6
    stop: 6e9
    value: 100e6
  states: {}
- name: rf_gain
  id: variable_qtgui_range
  parameters:
    start: '0'
    step: '1'
    stop: rf_gain_max
    value: rf_gain_max
  states: {}
- name: rf_gain_max
  id: variable
  parameters:
    value: '60'
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: 56e6
  states: {}
- name: waterfall_ms
  id: variable
  parameters:
    value: 1000*1024*976/samp_rate
  states: {}
- name: fosphor_glfw_sink_c_0
  id: fosphor_glfw_sink_c
  parameters:
    dBm_ref_0dBFS: dBm_ref_0dBFS
    freq_center: '0'
    freq_span: samp_rate
  states: {state: disabled}
- name: fosphor_qt_sink_c_0
  id: fosphor_qt_sink_c
  parameters:
    dBm_ref_0dBFS: dBm_ref_0dBFS
    freq_center: '0'
    freq_span: samp_rate
  states: {}
- name: uhd_usrp_source_0
  id: uhd_usrp_source
  parameters:
    ant0: '"TX/RX"'
    center_freq0: rf_freq
    dev_addr: ''
    gain0: rf_gain
    samp_rate: samp_rate
    sync: sync
    type: fc32
  states: {}

connections:
- [uhd_usrp_source_0, '0', fosphor_glfw_sink_c_0, '0']
- [uhd_usrp_source_0, '0', fosphor_qt_sink_c_0, '0']

metadata:
  file_format: 1
  grc_version: 3.10.9.2
